ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL MAC
HERE: SJMP HERE
ORG 130H
// *****************
MAC:
MOV A, 70H
MOV B, 73H
MUL AB
MOV R2, A
MOV R3, B
MOV A, 71H
MOV B, 74H
MUL AB
MOV R4, A
MOV R5, B
MOV A, 72H
MOV B, 75H
MUL AB
MOV R6, A
MOV R7, B
CALL ADD16
MOV R2, 52H
MOV R3, 51H
MOV A, R6
MOV R4, A
MOV A, R7
MOV R5, A
CALL ADD16
RET

ADD16:
MOV A, R2
MOV B, R4
ADD A, B
MOV 52H, A
MOV A, R3
MOV B, R5
ADDC A, B
MOV 51H, A
MOV A, 50H
ADDC A, #00H
MOV 50H, A
RET
END