ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL SORT
HERE: SJMP HERE
ORG 130H


SORT:
MOV R3, #08H
JNC OUTERLOOP
RET

OUTERLOOP:
DJNZ R3, INITIALIZE
JMP ASSIGN

ASSIGN:
MOV R0, #60H
MOV 70H, @R0
INC R0
MOV 71H, @R0
INC R0
MOV 72H, @R0
INC R0
MOV 73H, @R0
INC R0
MOV 74H, @R0
INC R0
MOV 75H, @R0
INC R0
MOV 76H, @R0
INC R0
MOV 77H, @R0
SETB C
JMP SORT

INITIALIZE:
MOV R0, #60H
MOV R1, #61H
MOV R4, #08H

INNERLOOP:
DJNZ R4, SWAPCHECK
JMP OUTERLOOP

SWAPCHECK:
MOV A, @R0
MOV B, @R1
SUBB A, B
JNC SWAPF

INCREMENT:
INC R0
INC R1
JMP INNERLOOP

SWAPF:
MOV A, @R0
MOV B, @R1
MOV R2, A
MOV A, B
MOV B, R2
MOV @R0, A
MOV @R1, B
JMP INCREMENT


END