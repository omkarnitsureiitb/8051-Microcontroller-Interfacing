ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL QUANT
HERE: SJMP HERE
ORG 130H


QUANT:
JNC INITIALIZE
RET

INITIALIZE:
MOV R2, #09H
MOV R0, #60H
MOV R1, #70H

LOOP:
DJNZ R2, QUANT1
SETB C
JMP QUANT

QUANT1:
MOV A, @R0
SUBB A, #0AH
MOV R3, #05H
JC STORE

QUANT2:
MOV A, @R0
SUBB A, #14H
MOV R3, #0FH
JC STORE

QUANT3:
MOV A, @R0
SUBB A, #1EH
MOV R3, #19H
JC STORE

QUANT4:
MOV R3, #23H
JMP STORE

STORE:
CLR C
MOV A, R3
MOV @R1, A
INC R0
INC R1
JMP LOOP

END