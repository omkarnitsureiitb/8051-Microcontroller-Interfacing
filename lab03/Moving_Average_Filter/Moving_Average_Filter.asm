ORG 0H
LJMP MAIN
ORG 100H
MAIN:
CALL FILT
HERE: SJMP HERE
ORG 130H


FILT:
JNC INITIALIZE
RET

INITIALIZE:
MOV 5DH, #00H
MOV 5EH, #00H
MOV 5FH, #00H
MOV R0, #5DH
MOV R1, #70H
MOV R6, #09H

LOOP:
DJNZ R6, ASSIGN
SETB C
JMP FILT

ASSIGN:
MOV B, @R0
MOV R2, B
INC R0
MOV A, R0
MOV B, @R0
MOV R3, B
INC R0
MOV B, @R0
MOV R4, B
INC R0
MOV B, @R0
MOV R5, B
MOV R0, A

CALC:
MOV A, R2
ADD A, R3
ADD A, R4
ADD A, R5
MOV B, #04H
DIV AB

STORE:
MOV @R1, A
INC R1
JMP LOOP

END